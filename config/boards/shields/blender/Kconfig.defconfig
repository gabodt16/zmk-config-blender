## config/boards/shields/blender/Kconfig.defconfig
```kconfig
if SHIELD_BLENDER

config ZKM_KEYBOARD_NAME
  string "Blender"
  default "Blender"

endif
```
